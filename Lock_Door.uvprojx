# Keil uVision project Lock_Door.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lock_Door
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./LCD/: lcd.h LCD.c
    ./Keypad/: keypad.c keypad.h
    ./: main.c Timer.c Timer.h
    ./UART/: uart.c
    ./GPIO_Drivers/: Data_Type.h GPIO.h Tiva_C_Ports.h TivaC_IO.h GPIO.c EEPROM.c EEPROM.h
  group inc
    ./: std_types.h tm4c123gh6pm.h
    ./UART/: uart.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
